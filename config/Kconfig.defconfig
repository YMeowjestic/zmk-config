## config/Kconfig.defconfig
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_p48n

config ZMK_KEYBOARD_NAME
	default "p48n"

endif
```
